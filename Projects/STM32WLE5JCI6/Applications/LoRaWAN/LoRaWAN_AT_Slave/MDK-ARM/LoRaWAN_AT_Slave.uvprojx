# Keil uVision project LoRaWAN_AT_Slave.uvprojx, settings and files
target LoRaWAN_AT_Slave (6190000::V6.19::ARMCLANG)
  device: STM32WLE5CCUx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") DSP CLOCK(12000000) ELITTLE
  output: LoRaWAN_AT_Slave +hex
  AfterMake: F:\keil5\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,HAS_FLOAT,STM32WLE5xx,REGION_EU868,WLE5JCI6
  c misc: -fshort-enums
  c include: ../Core/Inc;../LoRaWAN/App;../LoRaWAN/Target;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/trace/adv_trace;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\zb25vq32;..\..\..\..\..\..\Drivers\BSP\Components\ds18b20;..\..\..\..\..\..\Drivers\BSP\Components\sht3x;..\..\..\..\..\..\Drivers\BSP\Components\mcp3426;..\..\..\..\..\..\Middlewares\Core;..\..\..\..\..\..\Middlewares\Crypto;..\..\..\..\..\..\Middlewares\LoRaMac-node\region;..\..\..\..\..\..\Middlewares\LoRaMac-node;..\..\..\..\..\..\Drivers\BSP\Components\flash_eraseprogram;..\..\..\..\..\..\Drivers\BSP\Components\iwdg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: .\stm32wle5xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32wle5xx.s
  group Application/User/Core
    ../Core/Src/: main.c adc.c gpio.c dma.c flash_if.c stm32_lpm_if.c sys_app.c sys_debug.c timer_if.c adc_if.c usart_if.c usart.c rtc.c subghz.c stm32wlxx_it.c stm32wlxx_hal_msp.c bsp.c
    ../LoRaWAN/App/: lora_app.c
  group Application/User/LoRaWAN/Target
    ../LoRaWAN/Target/: radio_board_if.c
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c radio_fw.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/zb25vq32/: zb25vq32.c
    ../../../../../../Drivers/BSP/Components/ds18b20/: ds18b20.c
    ../../../../../../Drivers/BSP/Components/mcp3426/: mcp3426.c
    ../../../../../../Drivers/BSP/Components/flash_eraseprogram/: flash_eraseprogram.c
    ../../../../../../Drivers/BSP/Components/iwdg/: iwdg.c
    ../../../../../../Drivers/BSP/Components/sht3x/: i2c_hal.c sht3x.c
  group Application/User/LoRaWAN/App
    ../LoRaWAN/App/: lora_command.c
  group Middlewares/Lora/Mac/region
    ../../../../../../Middlewares/LoRaMac-node/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionKZ865.c RegionMA869.c RegionRU864.c RegionUS915.c
  group Middlewares/Lora/Mac
    ../../../../../../Middlewares/LoRaMac-node/: LoRaMac.c LoRaMacCrypto.c LoRaMacCommands.c
    ../../../../../../Middlewares/Core/: lora-test.c utilities.c
  group Middlewares/Lora/Crypto
    ../../../../../../Middlewares/Crypto/: aes.c cmac.c
software components: CMSIS:CORE 5.6.0
